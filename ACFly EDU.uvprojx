# Keil uVision project ACFly EDU.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ACFly EDU +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: PART_TM4C123GH6PM,ARM_MATH_CM4,TARGET_IS_TM4C123_RB1,__FPU_USED
  c include: .\Device\Include\TM4C123;.\Drivers;.\driverlib;.\;.\Basic;.\driverlib\inc;.\Math;.\MeasurementSystem;.\TS;.\InteractiveInterface;.\Filters;.\DataStructure;.\Communication;.\Modes;.\Communication\Mavlink;.\Communication\Mavlink\common_ACFly;.\ControlSystem;..\Rescue_lhq;.\laser;.\PID
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group BSP
    ./Device/Source/ARM/: startup_TM4C123.s
    ./Device/Source/: system_TM4C123.c
  group main
    ./: main.c
  group Drivers
    ./Drivers/: USB_def.c drv_main.c drv_LED.c drv_Sensors.c drv_USB.c Sensors.c drv_OLED.c drv_uDMA.c oledfont.c drv_Receiver.c Receiver.c drv_PWMOut.c drv_Ultrasonic.c drv_OpticalFlow.c drv_EEPROM.c drv_Uart2.c drv_ADC.c drv_Uart3.c drv_Laser.c drv_Uart0.c drv_Uart7.c I2C1.c drv_I2C1.h
  group DriverLib
    ./driverlib/rvmdk/: driverlib.lib
    ./driverlib/usblib/rvmdk/: usblib.lib
  group Basic
    ./Basic/: Basic.c Configurations.c
  group Math
    ./Math/: map_projection.h AC_Math.h Quaternion.h vector_3.c
    ./Drivers/: Quaternion.c
  group MeasurementSystem
    ./MeasurementSystem/: MS_main.c MeasurementSystem.h MS_Attitude.lib MS_Position.lib
  group TaskScheduling
    ./TS/: STS.c
  group InteractiveInterface
    ./InteractiveInterface/: InteractiveInterface.h OLED_Screens.c
  group Filters
    ./Filters/: Filters_Butter.c TD4.h PositionKalmanFilter.h
  group DataStructure
    ./DataStructure/: RingBuf.h
  group Communication
    ./Communication/: Debug.c Mavlink.c MavlinkSendFuncs.c CommuLink.c MavlinkCMDProcess.c MavlinkRCProcess.c
  group Modes
    ./Modes/: Modes.c M00_init.c M01_Ground.c M10_RCCalib.c M12_AccCalib.c M13_MagCalib.c M15_HorizontalCalib.c M30_Att.c M32_PosCtrl.c M37.c
  group ControlSystem
    ./ControlSystem/: Ctrl_main.c ctrl_Attitude.c ctrl_Position.c ESO_AngularRate.h ESO_h.h ControlSystem.h
  group Replace Text
    ./Document/: Replace.txt
  group Laser
    ./laser/: nlink_tofsense_frame0.c nlink_tofsense_frame0.h nlink_typedef.h nlink_utils.c nlink_utils.h
  group PID
    ./PID/: pid.c my_basic_control.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
